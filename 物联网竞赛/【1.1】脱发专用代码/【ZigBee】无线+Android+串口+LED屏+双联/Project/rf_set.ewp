# IAR project rf_set.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
configuration send (8051, debug)
  as the first configuration, except:
configuration recv (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle; ..\CC2530_lib\sensor_drv; ..\CC2530_lib\hal_led.h
  group app
    ./: recv.c send.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.c
  group board
    ../CC2530_LIB/board/: hal_board.c
    ../CC2530_lib/board/: hal_i2c.c hal_led.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c
    ../CC2530_LIB/common/: hal_uart.c
  group mylib
    ../CC2530_lib/mylib/: UART_PRINT.c
  group sensor_drv
    SENSOR_DRV/: get_adc.c get_adc.h
    sensor_drv/: sht.c sht1x.c sht3x.c
  group utils
    ../CC2530_lib/utils/: util.c
