<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x547C;&#x5438;&#x706F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


