<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5149;&#x7167;&#x7535;&#x538B;&#x63A7;&#x5236;&#x706F;&#x5149;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


